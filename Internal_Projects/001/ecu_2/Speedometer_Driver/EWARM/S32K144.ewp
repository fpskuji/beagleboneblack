# IAR project S32K144.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED; IAR
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application; ..\MCAL\Port\include; ..\MCAL\Icu\include; ..\MCAL\Dio\include; ..\MCAL\Det\include; ..\MCAL\Base\include; ..\MCAL\Rte\include; ..\SETUP_FILES\include; ..\LED\output\include; ..\MCAL\Dem\include; ..\MCAL\Mcu\include; ..\MCAL\Gpt\include; ..\MCAL\EcuM\include; ..\MCAL\Mcl\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S32K144.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: main.c
  group EB_Config/src
    ../LED/output/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group MCAL/Dem
    ../MCAL/Dem/src/: Dem.c
  group MCAL/Det
    ../MCAL/Det/src/: Det.c
  group MCAL/EcuM
    ../MCAL/EcuM/src/: EcuM.c
  group MCAL/Gpt
    ../MCAL/Gpt/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group MCAL/Icu
    ../MCAL/Icu/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
  group MCAL/Mcl
    ../MCAL/Mcl/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group MCAL/Mcu
    ../MCAL/Mcu/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/Port
    ../MCAL/Port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/Rte
    ../MCAL/Rte/src/: SchM_Gpt.c SchM_Icu.c SchM_Mcu.c SchM_Port.c
  group SETUP_FILES
    ../SETUP_FILES/src/: LM393_Speed_Sensor.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
