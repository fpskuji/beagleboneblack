# IAR project Ecu2Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; AUTOSAR_OS_NOT_USED; CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../include; ../Startup; ../EBConfig_Ecu2Main/output/include; ../Drivers/Display; ../Drivers/RGB; ../Drivers/MotorandServo; ../Drivers/SpeedSensor; ../Drivers/BTModule; ../MCAL/BASE/include; ../MCAL/CAN/include; ../MCAL/CANIF/include; ../MCAL/DET/include; ../MCAL/DIO/include; ../MCAL/ECUM/include; ../MCAL/GPT/include; ../MCAL/MCL/include; ../MCAL/MCU/include; ../MCAL/OS/include; ../MCAL/PORT/include; ../MCAL/PWM/include; ../MCAL/RTE/include; ../MCAL/SPI/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ecu2Main.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application
    ./: main.c s32k1xx_it.c system.c
    ../Startup/: startup_S32K144.s system_S32K144.c
  group Drivers/BTModule
    ../Drivers/BTModule/: LPUART.c
  group Drivers/Display
    ../Drivers/Display/: fonts.c ILI9341.c printf.c
  group Drivers/MotorandServo
    ../Drivers/MotorandServo/: Motor.c Motor_Config.c Motor_Driver.c Servo.c
  group Drivers/RGB
    ../Drivers/RGB/: RGB.c
  group Drivers/SpeedSensor
    ../Drivers/SpeedSensor/: LM393_Speed_Sensor.c
  group EB
    ../EBConfig_Ecu2Main/output/src/: Can_Cfg.c Can_PBcfg.c CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c Pwm_PBcfg.c Spi_Cfg.c Spi_PBcfg.c
  group MCAL/CAN
    ../MCAL/CAN/src/: Can.c Can_Flexcan.c Can_Irq.c
  group MCAL/CANIF
    ../MCAL/CANIF/src/: CanIf.c
  group MCAL/DET
    ../MCAL/DET/src/: Det.c
  group MCAL/DIO
    ../MCAL/DIO/src/: Dio.c Dio_Gpio.c
  group MCAL/ECUM
    ../MCAL/ECUM/src/: EcuM.c
  group MCAL/GPT
    ../MCAL/GPT/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group MCAL/MCL
    ../MCAL/MCL/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group MCAL/MCU
    ../MCAL/MCU/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/OS
    ../MCAL/OS/src/: Os_counter_api.c
  group MCAL/PORT
    ../MCAL/PORT/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/PWM
    ../MCAL/PWM/src/: Pwm.c Pwm_FlexIO.c Pwm_Ftm.c Pwm_Ipw.c
  group MCAL/RTE
    ../MCAL/RTE/src/: SchM_Can.c SchM_Dio.c SchM_Gpt.c SchM_Mcl.c SchM_Mcu.c SchM_Port.c SchM_Pwm.c SchM_Spi.c
  group MCAL/SPI
    ../MCAL/SPI/src/: Spi.c Spi_FlexIO.c Spi_FlexIO_Irq.c Spi_IPW.c Spi_LPspi.c Spi_LPspi_Irq.c
