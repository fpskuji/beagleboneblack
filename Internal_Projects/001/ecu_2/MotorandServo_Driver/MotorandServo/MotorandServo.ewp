# IAR project MotorandServo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; AUTOSAR_OS_NOT_USED; CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../include; ../Startup; API; EBConfig/output/include; MCAL/BASE/include; MCAL/DEM/include; MCAL/DET/include; MCAL/MCL/include; MCAL/MCU/include; MCAL/PORT/include; MCAL/PWM/include; MCAL/RTE/include; MCAL/DIO/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MotorandServo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group API
    API/: Motor.c Motor_Config.c Motor_Driver.c RGB.c Servo.c
  group Application
    ./: main.c s32k1xx_it.c system.c
    ../Startup/: startup_S32K144.s system_S32K144.c
  group EB
    EBConfig/output/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c Pwm_PBcfg.c
  group MCAL/DEM
    MCAL/DEM/src/: Dem.c
  group MCAL/DET
    MCAL/DET/src/: Det.c
  group MCAL/DIO
    MCAL/DIO/src/: Dio.c Dio_Gpio.c
  group MCAL/MCL
    MCAL/MCL/src/: Ftm_Common.c Lpit_Common.c Lptmr_Common.c
  group MCAL/MCU
    MCAL/MCU/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/PORT
    MCAL/PORT/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/PWM
    MCAL/PWM/src/: Pwm.c Pwm_FlexIO.c Pwm_Ftm.c Pwm_Ipw.c
  group MCAL/RTE
    MCAL/RTE/src/: SchM_Mcl.c SchM_Mcu.c SchM_Port.c SchM_Pwm.c
