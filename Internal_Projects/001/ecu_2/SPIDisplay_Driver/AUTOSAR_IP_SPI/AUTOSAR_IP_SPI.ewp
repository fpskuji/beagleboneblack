# IAR project AUTOSAR_IP_SPI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: Drivers\MCAL\Include; Drivers\Include; Drivers\SPI_Display\Include; Drivers\EB_Config\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AUTOSAR_IP_SPI.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: main.c startup_S32K144.s
  group Drivers/MCAL
    Drivers/MCAL/Src/: CDD_Mcl.c Dem.c Det.c Dio.c Dio_Gpio.c Mcl_Dma.c Mcl_Dma_Irq.c Mcl_DmaMux.c Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c Port.c Port_Ipw.c Port_Port_Ci.c SchM_Dio.c SchM_Mcl.c SchM_Mcu.c SchM_Port.c SchM_Spi.c Spi.c Spi_FlexIO.c Spi_FlexIO_Irq.c Spi_IPW.c Spi_LPspi.c Spi_LPspi_Irq.c
  group Drivers/Src
    Drivers/Src/: initializations.c system_S32K144.c
  group EB_Config
    Drivers/EB_Config/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c Spi_Cfg.c Spi_PBcfg.c
  group SPI_Display
    Drivers/SPI_Display/Src/: fonts.c ILI9341.c
