<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AUTOSAR_IP_SPI.ewp</path>
    </project>
    <batchBuild />
</workspace>
