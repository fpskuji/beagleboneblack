# IAR project Project.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: FLASH; CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED; IAR
  ICCARM.CCIncludePath2: ..\Startup; ..\include; ..\MCAL\Base\include; ..\MCAL\Dem\include; ..\MCAL\Det\include; ..\MCAL\Dio\include; ..\MCAL\EcuM\include; ..\MCAL\Gpt\include; ..\MCAL\Mcl\include; ..\MCAL\Mcu\include; ..\MCAL\Port\include; ..\MCAL\Rte\include; ..\MCAL\Icu\include; ..\MCAL\Can\include; ..\MCAL\CanIf\include; ..\MCAL\Os\include; ..\Stub\include; D:\Internal_project\GAM_PHIL_Internal.EmbedTraining\Internal_Projects\001\ecu_1\CAN_Driver\Project\output\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; ..\include
  ILINK.IlinkIcfFile: ../config/S32K144_ram.icf
  group Application
    ./: main.c
  group EB_Config/src
    ../../Project/output/src/: Can_Cfg.c Can_PBcfg.c CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group MCAL/Can
    ../MCAL/Can/src/: Can.c Can_Flexcan.c Can_Irq.c
  group MCAL/CanIf
    ../MCAL/CanIf/src/: CanIf.c
  group MCAL/Dem
    ../MCAL/Dem/src/: Dem.c
  group MCAL/Det
    ../MCAL/Det/src/: Det.c
  group MCAL/Dio
    ../MCAL/Dio/src/: Dio.c Dio_Gpio.c
  group MCAL/EcuM
    ../MCAL/Ecum/src/: EcuM.c
  group MCAL/Gpt
    ../MCAL/Gpt/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group MCAL/Icu
    ../MCAL/Icu/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
  group MCAL/Mcl
    ../MCAL/Mcl/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group MCAL/Mcu
    ../MCAL/Mcu/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/Os
    ../MCAL/Os/src/: Os_counter_api.c
  group MCAL/Port
    ../MCAL/Port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/Rte
    ../MCAL/Rte/src/: SchM_Can.c SchM_Dio.c SchM_Gpt.c SchM_Icu.c SchM_Mcu.c SchM_Port.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
  group Stub
    ../Stub/src/: Flexcan.c IT_Controller.c IT_Handler.c Ultrasonic.c
