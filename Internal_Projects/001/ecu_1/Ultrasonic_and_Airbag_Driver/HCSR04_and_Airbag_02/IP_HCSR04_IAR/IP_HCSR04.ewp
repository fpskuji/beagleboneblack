# IAR project IP_HCSR04.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: EB_Generated\include; include; MCAL\BASE\include; MCAL\DEM\include; MCAL\DET\include; MCAL\DIO\include; MCAL\ECUM\include; MCAL\GPT\include; MCAL\ICU\include; MCAL\MCL\include; MCAL\MCU\include; MCAL\PORT\include; MCAL\RTE\include; Project_Settings\Startup_Code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EB_Generated
    EB_Generated/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
    EB_Generated/include/: CDD_Mcl_Cfg.h Dem_IntErrId.h Dio_Cfg.h EcuM_Cfg.h Gpt_Cfg.h Icu_Cfg.h Mcu_Cfg.h modules.h Port_Cfg.h Soc_Ips.h
  group include
    include/: Airbag_Logic.h GPT_ICU.h HCSR04.h interrupt.h main.h RGB_LED.h
  group MCAL
    MCAL/MCL/src/: CDD_Mcl.c Ftm_Common.c LPit_Common.c Lptmr_Common.c Mcl_Dma.c Mcl_Dma_Irq.c Mcl_DmaMux.c Mcl_FlexIO_Common.c Mcl_FlexIO_Irq.c Mcl_IPW.c Mcl_Lmem.c Mcl_TrgMux.c
    MCAL/DEM/src/: Dem.c
    MCAL/DET/src/: Det.c
    MCAL/DIO/src/: Dio.c Dio_Gpio.c
    MCAL/ECUM/src/: EcuM.c
    MCAL/GPT/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
    MCAL/ICU/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
    MCAL/BASE/include/: Mcal.h
    MCAL/MCL/include/: Mcl.h Mcl_Dma.h Mcl_TrgMux.h
    MCAL/MCU/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
    MCAL/MCU/include/: Mcu_IPW_Irq.h Mcu_IPW_Types.h
    MCAL/PORT/src/: Port.c Port_Ipw.c Port_Port_Ci.c
    MCAL/RTE/src/: SchM_Adc.c SchM_Can.c SchM_Crcu.c SchM_Crypto.c SchM_Dio.c SchM_Eep.c SchM_Eth.c SchM_Fee.c SchM_Fls.c SchM_Fr.c SchM_Gpt.c SchM_I2c.c SchM_Icu.c SchM_Iseled.c SchM_Lin.c SchM_Mcem.c SchM_Mcl.c SchM_Mcu.c SchM_Ocu.c SchM_Port.c SchM_Pwm.c SchM_RamTst.c SchM_Spi.c SchM_Wdg.c
  group src
    src/: Airbag_Logic.c GPT_ICU.c HCSR04.c interrupt.c main.c RGB_LED.c
  group Startup_Code
    Project_Settings/Startup_Code/: callbacks.h devassert.h device_registers.h s32_core_cm4.h S32K144.h S32K144_features.h startup.c startup.h startup_S32K144.S status.h system_S32K144.c system_S32K144.h
