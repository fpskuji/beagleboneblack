# IAR project Backup of IP_HCSR04.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED
  ICCARM.CCIncludePath2: EB_Generated\include; include; MCAL\BASE\include; MCAL\DEM\include; MCAL\DET\include; MCAL\DIO\include; MCAL\ECUM\include; MCAL\GPT\include; MCAL\ICU\include; MCAL\MCL\include; MCAL\MCU\include; MCAL\PORT\include; MCAL\RTE\include; Project_Settings\Startup_Code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EB_Generated
    EB_Generated/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
    EB_Generated/include/: CDD_Mcl_Cfg.h Dem_IntErrId.h Dio_Cfg.h EcuM_Cfg.h Gpt_Cfg.h Icu_Cfg.h Mcu_Cfg.h modules.h Os_cfg.h Port_Cfg.h Soc_Ips.h
  group include
    include/: Airbag_Logic.h GPT_ICU.h HCSR04.h interrupt.h main.h RGB_LED.h
  group MCAL
    MCAL/BASE/include/: Adc_MemMap.h Can_GeneralTypes.h Can_MemMap.h Compiler.h Compiler_Cfg.h CompilerDefinition.h ComStack_Cfg.h ComStack_Types.h Crcu_MemMap.h Crypto_MemMap.h Csec_MemMap.h Dio_MemMap.h Eep_MemMap.h Eth_GeneralTypes.h Eth_MemMap.h EthSwitch_43_SJA1105P_MemMap.h EthSwt_43_SJA1110_MemMap.h EthTrcv_43_TJA110X_MemMap.h Fee_MemMap.h Fls_MemMap.h Fr_GeneralTypes.h Fr_MemMap.h Gpt_MemMap.h I2c_MemMap.h Icu_MemMap.h Iseled_MemMap.h Lin_GeneralTypes.h Lin_MemMap.h Mcal.h Mcem_MemMap.h Mcl_MemMap.h Mcu_MemMap.h Ocu_MemMap.h Platform_Types.h Port_MemMap.h Pwm_MemMap.h Reg_eSys.h RegLockMacros.h SilRegMacros.h Spi_MemMap.h Std_Types.h StdRegMacros.h Wdg_MemMap.h
    MCAL/MCL/src/: CDD_Mcl.c Ftm_Common.c LPit_Common.c Lptmr_Common.c Mcl_Dma.c Mcl_Dma_Irq.c Mcl_DmaMux.c Mcl_FlexIO_Common.c Mcl_FlexIO_Irq.c Mcl_IPW.c Mcl_Lmem.c Mcl_TrgMux.c
    MCAL/MCL/include/: CDD_Mcl.h Ftm_Common.h Ftm_Common_Types.h Mcl.h Mcl_Dma.h Mcl_Dma_Types.h Mcl_DmaMux.h Mcl_DmaMux_Types.h Mcl_EnvCfg.h Mcl_FlexIO_Common.h Mcl_FlexIO_Common_Types.h Mcl_IPW.h Mcl_IPW_Notif.h Mcl_IPW_Types.h Mcl_Lmem.h Mcl_Lmem_Types.h Mcl_Notif.h Mcl_TrgMux.h Mcl_TrgMux_Types.h Mcl_Types.h Reg_eSys_Dma.h Reg_eSys_DmaMux.h Reg_eSys_FlexIO.h Reg_eSys_Ftm.h Reg_eSys_Lmem.h Reg_eSys_LPit.h Reg_eSys_Lptmr.h Reg_eSys_TrgMux.h
    MCAL/DEM/src/: Dem.c
    MCAL/DEM/include/: Dem.h Dem_Types.h
    MCAL/DET/src/: Det.c
    MCAL/DET/include/: Det.h
    MCAL/DIO/src/: Dio.c Dio_Gpio.c
    MCAL/DIO/include/: Dio.h Dio_EnvCfg.h Dio_Gpio.h Dio_Ipw.h Dio_Reg_eSys_Gpio.h
    MCAL/ECUM/src/: EcuM.c
    MCAL/ECUM/include/: EcuM.h EcuM_Cbk.h
    MCAL/GPT/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
    MCAL/GPT/include/: Gpt.h Gpt_EnvCfg.h Gpt_Ftm.h Gpt_Ftm_Types.h Gpt_Ipw.h Gpt_Ipw_Irq.h Gpt_Ipw_Types.h Gpt_Irq.h Gpt_LPit.h Gpt_LPit_Types.h Gpt_Lptmr.h Gpt_Lptmr_Types.h Gpt_SRtc.h Gpt_SRtc_Types.h Reg_eSys_SRtc.h
    MCAL/ICU/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
    MCAL/ICU/include/: Icu.h Icu_EnvCfg.h Icu_Ftm.h Icu_Ftm_Irq.h Icu_Ftm_Types.h Icu_Ipw.h Icu_Ipw_Irq.h Icu_Ipw_Types.h Icu_Irq.h Icu_LPit.h Icu_LPit_Types.h Icu_Lptmr.h Icu_Lptmr_Types.h Icu_Port_Ci.h Icu_Port_Ci_Types.h Icu_Reg_eSys_Port_Ci.h Icu_Types.h
    MCAL/MCU/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
    MCAL/MCU/include/: Mcu.h Mcu_CMU.h Mcu_CMU_IPVersion.h Mcu_CMU_Types.h Mcu_CortexM4.h Mcu_CortexM4_Types.h Mcu_EnvCfg.h Mcu_IPW.h Mcu_IPW_Irq.h Mcu_IPW_Types.h Mcu_PCC.h Mcu_PCC_Types.h Mcu_PMC.h Mcu_PMC_IPVersion.h Mcu_PMC_Types.h Mcu_RCM.h Mcu_RCM_Types.h Mcu_SCG.h Mcu_SCG_Types.h Mcu_SIM.h Mcu_SIM_Types.h Mcu_SMC.h Mcu_SMC_Types.h Reg_eSys_CMU.h Reg_eSys_CortexM4.h Reg_eSys_PCC.h Reg_eSys_PMC.h Reg_eSys_RCM.h Reg_eSys_SCG.h Reg_eSys_SIM.h Reg_eSys_SMC.h
    MCAL/PORT/src/: Port.c Port_Ipw.c Port_Port_Ci.c
    MCAL/PORT/include/: Port.h Port_EnvCfg.h Port_Ipw.h Port_Port_Ci.h Port_Port_Ci_Types.h Port_Reg_eSys_Gpio.h Port_Reg_eSys_Port_Ci.h Reg_eSys_Gpio.h
    MCAL/RTE/src/: SchM_Adc.c SchM_Can.c SchM_Crcu.c SchM_Crypto.c SchM_Dio.c SchM_Eep.c SchM_Eth.c SchM_Fee.c SchM_Fls.c SchM_Fr.c SchM_Gpt.c SchM_I2c.c SchM_Icu.c SchM_Iseled.c SchM_Lin.c SchM_Mcem.c SchM_Mcl.c SchM_Mcu.c SchM_Ocu.c SchM_Port.c SchM_Pwm.c SchM_RamTst.c SchM_Spi.c SchM_Wdg.c
    MCAL/RTE/include/: SchM_Adc.h SchM_Can.h SchM_Crcu.h SchM_Crypto.h SchM_Dio.h SchM_Eep.h SchM_Eth.h SchM_Fee.h SchM_Fls.h SchM_Fr.h SchM_Gpt.h SchM_I2c.h SchM_Icu.h SchM_Iseled.h SchM_Lin.h SchM_Mcem.h SchM_Mcl.h SchM_Mcu.h SchM_Ocu.h SchM_Port.h SchM_Pwm.h SchM_RamTst.h SchM_Spi.h SchM_Wdg.h
  group src
    src/: Airbag_Logic.c GPT_ICU.c HCSR04.c interrupt.c main.c RGB_LED.c
  group Startup_Code
    Project_Settings/Startup_Code/: callbacks.h devassert.h device_registers.h s32_core_cm4.h S32K144.h S32K144_features.h startup.c startup.h startup_S32K144.S status.h system_S32K144.c system_S32K144.h
