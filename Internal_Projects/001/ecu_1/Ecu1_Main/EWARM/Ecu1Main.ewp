# IAR project Ecu1Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR; AUTOSAR_OS_NOT_USED; CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../include; ../Startup; ../EBConfig_Ecu1Main/output/include; ../Drivers/UltrasonicSensorandAirbag; ../Drivers/CarLights; ..\Drivers\BTModule; ..\Drivers\FlexCAN; ..\MCAL\BASE\include; ../MCAL/DET/include; ../MCAL/DIO/include; ../MCAL/ECUM/include; ../MCAL/GPT/include; ../MCAL/ICU/include; ../MCAL/MCL/include; ../MCAL/MCU/include; ../MCAL/PORT/include; ../MCAL/RTE/include; ../MCAL/Can/include; ../MCAL/Canif/include; ..\MCAL\Os\include; ..\MCAL\Dem\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ecu1Main.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ./: main.c s32k1xx_it.c
    ../Startup/: startup_S32K144.s system_S32K144.c
  group Drivers/BTModule
    ../Drivers/BTModule/: LPUART.c
  group Drivers/CAN
    ../Drivers/FlexCAN/: Flexcan.c
  group Drivers/CarLights
    ../Drivers/CarLights/: ledindication.c
  group Drivers/UltrasonicSensor
    ../Drivers/UltrasonicSensorandAirbag/: Airbag_Logic.c GPT_ICU.c HCSR04.c interrupt.c RGB_LED.c
  group EB
    ../EBConfig_Ecu1Main/output/src/: Can_Cfg.c Can_PBcfg.c CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group MCAL/CAN
    ../MCAL/Can/src/: Can.c Can_Flexcan.c Can_Irq.c
  group MCAL/Canif
    ../MCAL/CanIf/src/: CanIf.c
  group MCAL/DET
    ../MCAL/DET/src/: Det.c
  group MCAL/DIO
    ../MCAL/DIO/src/: Dio.c Dio_Gpio.c
  group MCAL/ECUM
    ../MCAL/ECUM/src/: EcuM.c
  group MCAL/GPT
    ../MCAL/GPT/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group MCAL/ICU
    ../MCAL/ICU/src/: Icu.c Icu_Ftm.c Icu_Ipw.c Icu_LPit.c Icu_Lptmr.c Icu_Port_Ci.c Icu_Port_Ci_Irq.c
  group MCAL/MCL
    ../MCAL/MCL/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group MCAL/MCU
    ../MCAL/MCU/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group MCAL/OS
    ../MCAL/Os/src/: Os_counter_api.c
  group MCAL/PORT
    ../MCAL/PORT/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group MCAL/RTE
    ../MCAL/RTE/src/: SchM_Can.c SchM_Dio.c SchM_Gpt.c SchM_Icu.c SchM_Mcl.c SchM_Mcu.c SchM_Port.c
